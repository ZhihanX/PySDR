options:
  parameters:
    author: zhihan
    generate_options: qt_gui
    id: Constant_pilot
    output_language: python
    title: Constant pilot22
  states: {}

blocks:
- name: LO
  id: variable
  parameters:
    value: '2450000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2500000'
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1000'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_2
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: '20000000'
    buffer_size: '10000'
    cyclic: 'False'
    filter_source: '''Off'''
    frequency: LO
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.4.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'False'
    buffer_size: '10000'
    filter_source: '''Off'''
    fpass: '80000'
    frequency: LO
    fstop: '120000'
    gain1: '''manual'''
    manual_gain1: '70.000'
    quadrature: 'True'
    rfdc: 'False'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '1000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '20000000'
    fc: '0'
    fftsize: '1024'
    name: '"Rx"'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    wintype: window.WIN_HANN
  states: {}
- name: qtgui_freq_sink_x_0_2
  id: qtgui_freq_sink_x
  parameters:
    bw: '20000000'
    fc: '0'
    fftsize: '1024'
    name: '"Tx"'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    wintype: window.WIN_HANN
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Rx"'
    size: '20000'
    srate: '2500000'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    name: '"RxMag"'
    size: '20000'
    srate: '2500000'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_2_0
  id: qtgui_time_sink_x
  parameters:
    name: '"TxMag"'
    size: '20000'
    srate: '2500000'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_3
  id: qtgui_time_sink_x
  parameters:
    name: '"Tx"'
    size: '20000'
    srate: '2500000'
    type: float
  states: {}

connections:
- [analog_sig_source_x_0_1, '0', blocks_complex_to_float_0_2, '0']
- [analog_sig_source_x_0_1, '0', blocks_complex_to_mag_1, '0']
- [analog_sig_source_x_0_1, '0', iio_pluto_sink_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_0_2, '0', qtgui_freq_sink_x_0_2, '0']
- [blocks_complex_to_float_0_2, '0', qtgui_time_sink_x_0_3, '0']
- [blocks_complex_to_mag_1, '0', qtgui_time_sink_x_0_2_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_2, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_float_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
